# IAR project Flash_BootSwap_Proj.ewp, settings and files
configuration N32A052_BOOT0 (ARM, debug)
  General.OGChipSelectEditMenu: N32A052KB Nations N32A052KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32A052; USE_STDPERIPH_DRIVER; BOOT0_START
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32a052_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_BootSwap_Proj.bin
  ILINK.IlinkOutputFile: Flash_BootSwap_Proj.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32A052_BOOT1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: N32A052; USE_STDPERIPH_DRIVER; BOOT1_START
  ILINK.IlinkIcfFile: Flash_BootSwap_Proj.icf
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a052.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32a052_std_periph_driver/src/: misc.c n32a052_flash.c n32a052_gpio.c n32a052_rcc.c n32a052_uart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a052_EWARM.S
  group USER
    ../src/: main.c n32a052_it.c
