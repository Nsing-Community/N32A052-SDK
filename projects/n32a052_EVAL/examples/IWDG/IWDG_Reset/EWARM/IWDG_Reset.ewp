# IAR project IWDG_Reset.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32A052KB Nations N32A052KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32A052; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32a052_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IWDG_Reset.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a052.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32a052_std_periph_driver/src/: misc.c n32a052_exti.c n32a052_gpio.c n32a052_iwdg.c n32a052_rcc.c n32a052_tim.c n32a052_uart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a052_EWARM.S
  group USER
    ../src/: main.c n32a052_it.c
