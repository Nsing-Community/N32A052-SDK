# Keil uVision project I2C_Master_Int.uvprojx, settings and files
target N32A052 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32A052KB Nationstech
  pack: Nationstech.N32A052_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) IROM2(0x1FFF1000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: I2C_Master_Int_Project +hex
  AfterMake: fromelf --bin --output=.\bin\I2C_Master_Int_Project.bin .\Objects\I2C_Master_Int_Project.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32A052, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32a052_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff1000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a052.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a052.c
  group FWLB
    ../../../../../../firmware/n32a052_std_periph_driver/src/: misc.c n32a052_gpio.c n32a052_i2c.c n32a052_rcc.c n32a052_uart.c
  group USER
    ../src/: main.c n32a052_it.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
