# Keil uVision project JumpToBoot.uvprojx, settings and files
target N32A052 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32A052KB Nationstech
  pack: Nationstech.N32A052_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) IROM2(0x1FFF1000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: JumpToBoot +hex
  AfterMake: fromelf --bin --output=.\bin\JumpToBoot.bin .\Objects\JumpToBoot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32A052, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\firmware\n32a052_std_periph_driver\inc;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff1000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../../../../../firmware/CMSIS/device/startup/: startup_n32a052.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_n32a052.c
  group Driver
    ../../../../../firmware/n32a052_std_periph_driver/src/: misc.c n32a052_flash.c n32a052_gpio.c n32a052_iwdg.c n32a052_rcc.c n32a052_uart.c
  group User
    ../src/: main.c
  group Bsp
    ../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
